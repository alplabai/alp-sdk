# SPDX-License-Identifier: Apache-2.0
# The package's DEV table is keyed on the `rzv2n-evk` override, which our
# MACHINEs do not carry; the RZ/V2N Secure IP library is the V2H one.
DEV = "v2h"
